v {xschem version=3.4.7RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
P 4 1 -310 -30 {}
P 4 1 -260 -20 {}
N -130 -80 -110 -80 {lab=#net1}
N -240 -80 -230 -80 {lab=EN}
N 90 -60 140 -60 {lab=OUT}
N -180 -100 -110 -100 {lab=IN1}
N -150 -40 -110 -40 {lab=IN1}
N -150 -50 -150 -40 {lab=IN1}
N -150 -100 -150 -50 {lab=IN1}
N -180 -20 -110 -20 {lab=IN2}
N -20 -90 -20 -70 {lab=#net2}
N -20 -70 0 -70 {lab=#net2}
N -20 -50 -20 -30 {lab=#net3}
N -20 -50 0 -50 {lab=#net3}
N -260 -100 -180 -100 {lab=IN1}
N -260 -20 -180 -20 {lab=IN2}
N -260 -80 -240 -80 {lab=EN}
C {ipin.sym} -260 -80 0 0 {name=p1 lab=EN}
C {ipin.sym} -260 -100 0 0 {name=p3 lab=IN1}
C {opin.sym} 140 -60 0 0 {name=p4 lab=OUT}
C {ipin.sym} -260 -20 0 0 {name=p2 lab=IN2}
C {LR_Work2/symbol/2NANDLR.sym} 40 -30 0 0 {name=x2}
C {LR_Work2/symbol/2NANDLR.sym} 150 -60 0 0 {name=x3}
C {LR_Work2/symbol/2NANDLR.sym} 40 -90 0 0 {name=x4}
C {LR_Work2/symbol/INVERTER.sym} 10 -80 0 0 {name=x1}
